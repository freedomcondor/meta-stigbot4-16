IMAGE_INSTALL += " netinterface \
"

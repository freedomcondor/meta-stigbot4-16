IMAGE_INSTALL += " argos \
"

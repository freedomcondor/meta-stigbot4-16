IMAGE_INSTALL += " pmstatus \
"

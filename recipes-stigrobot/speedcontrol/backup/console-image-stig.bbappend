IMAGE_INSTALL += " speedcontrol \
"
